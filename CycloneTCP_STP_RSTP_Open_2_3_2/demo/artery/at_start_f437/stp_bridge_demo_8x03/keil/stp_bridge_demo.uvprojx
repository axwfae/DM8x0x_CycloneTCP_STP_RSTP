# Keil uVision project stp_bridge_demo.uvprojx, settings and files
target stp_bridge_demo_flash (ARM-ADS)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.5
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x3F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rstp_bridge_demo_flash
  BeforeMake: ..\..\..\..\..\utils\ResourceCompiler\bin\rc.exe ..\resources\ ..\src\res.c
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: AT32F437ZMT7 AT_START_F437_V1
  c include: ..\src;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\artery\devices\at32f435_437;..\..\..\..\..\third_party\artery\devices\at32f435_437\drivers\inc;..\..\..\..\..\third_party\artery\boards\at32f435_437_board;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm4f;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp;..\..\..\..\..\cyclone_stp;..\..\..\..\..\cyclone_crypto
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: .\at32f437_flash.sct
  group Demo Sources
    ./: startup_at32f435_437.s retarget.c
    ../src/: at32f435_437_clock.c at32f435_437_int.c system_at32f435_437.c main.c debug.c res.c
  group Demo Headers
    ../src/: os_port_config.h net_config.h FreeRTOSConfig.h at32f435_437_conf.h at32f435_437_clock.h at32f435_437_int.h crypto_config.h stp_config.h
  group Common Sources
    ../../../../../common/: cpu_endian.c os_port_freertos.c date_time.c str.c path.c resource_manager.c
  group Common Headers
    ../../../../../common/: cpu_endian.h os_port.h os_port_freertos.h date_time.h str.h path.h resource_manager.h error.h debug.h
  group CycloneTCP Sources
    ../../../../../cyclone_tcp/core/: net.c net_mem.c net_misc.c nic.c ethernet.c ethernet_misc.c ip.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c socket.c socket_misc.c bsd_socket.c bsd_socket_options.c bsd_socket_misc.c raw_socket.c
    ../../../../../cyclone_tcp/drivers/mac/: at32f4xx_eth_driver.c
    ../../../../../cyclone_tcp/drivers/phy/: dm9162_driver.c
    ../../../../../cyclone_tcp/ipv4/: arp.c arp_cache.c ipv4.c ipv4_frag.c ipv4_misc.c icmp.c
    ../../../../../cyclone_tcp/igmp/: igmp_host.c igmp_host_misc.c igmp_common.c
    ../../../../../cyclone_tcp/ipv6/: ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c icmpv6.c mld.c ndp.c ndp_cache.c ndp_misc.c slaac.c slaac_misc.c
    ../../../../../cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cyclone_tcp/mdns/: mdns_client.c mdns_responder.c mdns_responder_misc.c mdns_common.c
    ../../../../../cyclone_tcp/netbios/: nbns_client.c nbns_responder.c nbns_common.c
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.c llmnr_responder.c llmnr_common.c
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.c dhcp_client_fsm.c dhcp_client_misc.c dhcp_common.c dhcp_debug.c
    ../../../../../cyclone_tcp/http/: http_server.c http_server_auth.c http_server_misc.c mime.c ssi.c
    ../../../../../cyclone_tcp/drivers/switch/: dm8x06_driver.c dm8x03_driver.c
    ../../../../../cyclone_tcp/snmp/: snmp_agent.c snmp_agent_dispatch.c snmp_agent_inform.c snmp_agent_message.c snmp_agent_misc.c snmp_agent_object.c snmp_agent_pdu.c snmp_agent_trap.c snmp_agent_usm.c snmp_agent_vacm.c
    ../../../../../cyclone_tcp/mibs/: mib_common.c snmp_mib_impl.c snmp_mib_module.c
  group CycloneTCP Headers
    ../../../../../cyclone_tcp/core/: net.h net_mem.h net_misc.h nic.h ethernet.h ethernet_misc.h ip.h tcp.h tcp_fsm.h tcp_misc.h tcp_timer.h udp.h socket.h socket_misc.h bsd_socket.h bsd_socket_options.h bsd_socket_misc.h raw_socket.h
    ../../../../../cyclone_tcp/drivers/mac/: at32f4xx_eth_driver.h
    ../../../../../cyclone_tcp/drivers/phy/: dm9162_driver.h
    ../../../../../cyclone_tcp/ipv4/: arp.h arp_cache.h ipv4.h ipv4_frag.h ipv4_misc.h icmp.h
    ../../../../../cyclone_tcp/igmp/: igmp_host.h igmp_host_misc.h igmp_common.h
    ../../../../../cyclone_tcp/ipv6/: ipv6.h ipv6_frag.h ipv6_misc.h ipv6_pmtu.h icmpv6.h mld.h ndp.h ndp_cache.h ndp_misc.h slaac.h slaac_misc.h
    ../../../../../cyclone_tcp/dns/: dns_cache.h dns_client.h dns_common.h dns_debug.h
    ../../../../../cyclone_tcp/mdns/: mdns_client.h mdns_responder.h mdns_responder_misc.h mdns_common.h
    ../../../../../cyclone_tcp/netbios/: nbns_client.h nbns_responder.h nbns_common.h
    ../../../../../cyclone_tcp/llmnr/: llmnr_client.h llmnr_responder.h llmnr_common.h
    ../../../../../cyclone_tcp/dhcp/: dhcp_client.h dhcp_client_fsm.h dhcp_client_misc.h dhcp_common.h dhcp_debug.h
    ../../../../../cyclone_tcp/http/: http_server.h http_server_auth.h http_server_misc.h mime.h ssi.h
    ../../../../../cyclone_tcp/drivers/switch/: dm8x06_driver.h dm8x03_driver.h
    ../../../../../cyclone_tcp/snmp/: snmp_agent.h snmp_agent_dispatch.h snmp_agent_inform.h snmp_agent_message.h snmp_agent_misc.h snmp_agent_object.h snmp_agent_pdu.h snmp_agent_trap.h snmp_agent_usm.h snmp_agent_vacm.h snmp_common.h
    ../../../../../cyclone_tcp/mibs/: mib_common.h snmp_mib_impl.h snmp_mib_module.h
  group FreeRTOS Sources
    ../../../../../third_party/freertos/portable/rvds/arm_cm4f/: port.c
    ../../../../../third_party/freertos/: croutine.c list.c queue.c tasks.c timers.c
    ../../../../../third_party/freertos/portable/memmang/: heap_3.c
  group FreeRTOS Headers
    ../../../../../third_party/freertos/portable/rvds/arm_cm4f/: portmacro.h
    ../../../../../third_party/freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h task.h timers.h
  group AT-START-F437 Sources
    ../../../../../third_party/artery/boards/at32f435_437_board/: at32f435_437_board.c
  group AT-START-F437 Headers
    ../../../../../third_party/artery/boards/at32f435_437_board/: at32f435_437_board.h
  group AT32F437 Drivers Sources
    ../../../../../third_party/artery/devices/at32f435_437/drivers/src/: at32f435_437_acc.c at32f435_437_adc.c at32f435_437_can.c at32f435_437_crc.c at32f435_437_crm.c at32f435_437_dac.c at32f435_437_debug.c at32f435_437_dma.c at32f435_437_dvp.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_ertc.c at32f435_437_exint.c at32f435_437_flash.c at32f435_437_gpio.c at32f435_437_i2c.c at32f435_437_misc.c at32f435_437_pwc.c at32f435_437_qspi.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_spi.c at32f435_437_tmr.c at32f435_437_usart.c at32f435_437_usb.c at32f435_437_wdt.c at32f435_437_wwdt.c at32f435_437_xmc.c
  group AT32F437 Drivers Headers
    ../../../../../third_party/artery/devices/at32f435_437/drivers/inc/: at32f435_437_acc.h at32f435_437_adc.h at32f435_437_can.h at32f435_437_crc.h at32f435_437_crm.h at32f435_437_dac.h at32f435_437_debug.h at32f435_437_def.h at32f435_437_dma.h at32f435_437_dvp.h at32f435_437_edma.h at32f435_437_emac.h at32f435_437_ertc.h at32f435_437_exint.h at32f435_437_flash.h at32f435_437_gpio.h at32f435_437_i2c.h at32f435_437_misc.h at32f435_437_pwc.h at32f435_437_qspi.h at32f435_437_scfg.h at32f435_437_sdio.h at32f435_437_spi.h at32f435_437_tmr.h at32f435_437_usart.h at32f435_437_usb.h at32f435_437_wdt.h at32f435_437_wwdt.h at32f435_437_xmc.h
  group CycloneSTP Sources_rstp
    ../../../../../cyclone_stp/rstp/: rstp.c rstp_bdm.c rstp_bpdu.c rstp_conditions.c rstp_fsm.c rstp_mgmt.c rstp_misc.c rstp_pim.c rstp_ppm.c rstp_procedures.c rstp_prs.c rstp_prt.c rstp_prx.c rstp_pst.c rstp_pti.c rstp_ptx.c rstp_tcm.c
    ../../../../../cyclone_stp/mibs/: bridge_mib_impl.c bridge_mib_impl_base.c bridge_mib_impl_static.c bridge_mib_impl_stp.c bridge_mib_impl_tp.c bridge_mib_module.c rstp_mib_impl.c rstp_mib_module.c
  group CycloneSTP Headers_rstp
    ../../../../../cyclone_stp/rstp/: rstp.h rstp_bdm.h rstp_bpdu.h rstp_conditions.h rstp_fsm.h rstp_mgmt.h rstp_misc.h rstp_pim.h rstp_ppm.h rstp_procedures.h rstp_prs.h rstp_prt.h rstp_prx.h rstp_pst.h rstp_pti.h rstp_ptx.h rstp_tcm.h
    ../../../../../cyclone_stp/mibs/: bridge_mib_impl.h bridge_mib_impl_base.h bridge_mib_impl_static.h bridge_mib_impl_stp.h bridge_mib_impl_tp.h bridge_mib_module.h rstp_mib_impl.h rstp_mib_module.h
  group CycloneCRYPTO Sources
    ../../../../../cyclone_crypto/hash/: md5.c sha1.c
    ../../../../../cyclone_crypto/cipher/: des.c aes.c
    ../../../../../cyclone_crypto/mac/: hmac.c
    ../../../../../cyclone_crypto/cipher_modes/: cbc.c cfb.c
    ../../../../../cyclone_crypto/encoding/: asn1.c oid.c
  group CycloneCRYPTO Headers
    ../../../../../cyclone_crypto/hash/: md5.h sha1.h
    ../../../../../cyclone_crypto/mac/: hmac.h
    ../../../../../cyclone_crypto/cipher/: aes.h des.h
    ../../../../../cyclone_crypto/cipher_modes/: cbc.h cfb.h
    ../../../../../cyclone_crypto/encoding/: asn1.h oid.h
  group CycloneSTP Sources_stp
    ../../../../../cyclone_stp/stp/: stp.c stp_bpdu.c stp_conditions.c stp_mgmt.c stp_misc.c stp_operation.c stp_procedures.c
  group CycloneSTP Headers_stp
    ../../../../../cyclone_stp/stp/: stp.h stp_bpdu.h stp_common.h stp_conditions.h stp_mgmt.h stp_misc.h stp_operation.h stp_procedures.h
target stp_bridge_demo_sram (ARM-ADS)
  device: -AT32F437ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.5
  cpu: as above
  output: rstp_bridge_demo_sram
  BeforeMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: AT32F437ZMT7 AT_START_F437_V1
  c include: ..\src;..\..\..\..\..\third_party\cmsis\include;..\..\..\..\..\third_party\artery\devices\at32f435_437;..\..\..\..\..\third_party\artery\devices\at32f435_437\drivers\inc;..\..\..\..\..\third_party\artery\boards\at32f435_437_board;..\..\..\..\..\third_party\freertos\include;..\..\..\..\..\third_party\freertos\portable\rvds\arm_cm4f;..\..\..\..\..\common;..\..\..\..\..\cyclone_tcp
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: .\at32f437_sram.sct
